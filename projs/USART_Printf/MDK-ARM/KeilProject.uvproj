# Keil uVision project KeilProject.uvproj, settings and files
target STM32F4-Discovery (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: KeilProject +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,MANGUSTA_DISCOVERY,USE_USB_OTG_FS,HSE_VALUE=8000000
  c include: ..\src;..\..\..\lib\CMSIS\Include;..\..\..\lib\CMSIS\ST\STM32F4xx\Include;..\..\..\lib\STM32F4-Discovery;..\..\..\lib\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: stm32f4xx_conf.h main.h main.c stm32f4xx_it.h stm32f4xx_it.c
  group STM32F4-Discovery
    ../../../lib/STM32F4-Discovery/: stm32f4_discovery.h stm32f4_discovery.c
  group STM32F4xx_StdPeriph_Driver
    ../../../lib/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group MDK-ARM
    ../../../lib/CMSIS/ST/STM32F4xx/Source/: system_stm32f4xx.c
    ./: startup_stm32f4xx.s
